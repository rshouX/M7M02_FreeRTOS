# Keil uVision project kernel.uvprojx, settings and files
target Kernel (ARMCC)
  device: STM32F767IGTx STMicroelectronics
  cpu: IRAM(0x08000000,0x10000) IROM(0x20000000,0x10000) CPUTYPE("Cortex-M7")  CLOCK(12000000) ELITTLE
  output: Kernel +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c misc: -Wno-unknown-warning-option -Wno-unsafe-buffer-usage -Wno-date-time -Wno-unused-parameter -Wno-missing-noreturn -Wno-unsafe-buffer-usage -Wno-missing-variable-declarations
  c include: ./;../Include/;../../../../Include/Test/Chip/;../../../../../M7M01_Eukaron/Include/;
  asm include: as above
  library: MicroLIB
  scatter file: rme_platform_stm32f767ig.sct
  link misc: --keep=*_image
  group Kernel
    ../Source/: rme_hook.c rme_handler_tim4.c rme_boot.c
    ../../Virt1/Project/: virt1_image.c
    ../../Proc2/Project/: proc2_image.c
    ../../Proc1/Project/: proc1_image.c
    ../../Monitor/Project/: monitor_image.c
  group Lib
    ../../../../../M7M01_Eukaron/Source/Platform/A7M/: rme_platform_a7m_armcc.s rme_platform_a7m.c
    ../../../../../M7M01_Eukaron/Source/Kernel/: rme_kernel.c
