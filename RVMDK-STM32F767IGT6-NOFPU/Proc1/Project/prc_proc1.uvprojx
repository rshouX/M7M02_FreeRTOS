# Keil uVision project prc_proc1.uvprojx, settings and files
target Proc1 (ARMCC)
  device: STM32F767IGTx STMicroelectronics
  cpu: IRAM(0x08000000,0x10000) IROM(0x20000000,0x10000) CPUTYPE("Cortex-M7")  CLOCK(12000000) ELITTLE
  output: Proc1 +hex
  AfterMake: fromelf.exe --binCombined -o "$L@L.bin" "#L"
  AfterMake: ../../../../Utility/M7M02_Final/bincopy.exe -i $L@L.bin -o ./proc1_image.c
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c misc: -Wno-unknown-warning-option -Wno-unsafe-buffer-usage -Wno-date-time -Wno-unused-parameter -Wno-missing-noreturn -Wno-unsafe-buffer-usage -Wno-missing-variable-declarations
  c include: ./;../Include/;../../../../Include/;../../../../Guest/;
  asm include: ./;../Include/;../../../../Include/;../../../../Guest/;
  library: MicroLIB
  scatter file: prc_proc1_stm32f767ig.sct
  link misc: --keep=*_desc
  group Proc1
    ../Source/: prc_proc1_thd_thd2.c prc_proc1_thd_thd1.c prc_proc1_desc.c prc_proc1.c
  group Lib
    ../../../../Guest/: rvm_guest.c
    ../../../../Guest/A7M/: rvm_guest_a7m_armcc.s rvm_guest_a7m.c
