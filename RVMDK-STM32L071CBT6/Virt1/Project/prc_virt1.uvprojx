# Keil uVision project prc_virt1.uvprojx, settings and files
target Virt1 (6190000::V6.19::ARMCLANG)
  device: STM32L071CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x08000000,0x10000) IROM(0x20000000,0x10000) CPUTYPE("Cortex-M0+")  CLOCK(12000000) ELITTLE
  output: Virt1 +hex
  AfterMake: fromelf.exe --binCombined -o "$L@L.bin" "#L"
  AfterMake: ../../../../Utility/M7M02_Final/bincopy.exe -i $L@L.bin -o ./virt1_image.c
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c misc: -Wno-unknown-warning-option -Wno-unsafe-buffer-usage -Wno-date-time -Wno-unused-parameter -Wno-missing-noreturn -Wno-unsafe-buffer-usage -Wno-missing-variable-declarations
  c include: ./;../Include/;../../../../Include/;../../../../Guest/;..\..\..\..\Guest\A6M\FRT;..\..\..\..\..\M0A00_Library\FreeRTOS_V9.0.0\FreeRTOS\Source\include
  asm include: ./;../Include/;../../../../Include/;../../../../Guest/;../../../../../M5P01_Prokaron/Include/
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x8000000 size 0x10000
  scatter file: prc_virt1_stm32l071cb.sct
  link misc: --keep=*_desc
  group Virt1
    ../Source/: prc_virt1_desc.c prc_virt1.c
  group Lib
    ../../../../Guest/: rvm_guest.c
    ../../../../Guest/A6M/: rvm_guest_a6m_armcc.s rvm_guest_a6m.c
    ../../../../../M0A00_Library/FreeRTOS_V9.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../Guest/A6M/FRT/: port.c FreeRTOS_fast_yield_armcc.s
    ../../../../../M0A00_Library/FreeRTOS_V9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group User
    ../../../../Guest/A6M/FRT/: main.c
