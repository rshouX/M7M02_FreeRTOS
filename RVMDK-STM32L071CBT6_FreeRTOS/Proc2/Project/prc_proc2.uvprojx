# Keil uVision project prc_proc2.uvprojx, settings and files
target Proc2 (6190000::V6.19::ARMCLANG)
  device: STM32L071CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x08000000,0x10000) IROM(0x20000000,0x10000) CPUTYPE("Cortex-M0+")  CLOCK(12000000) ELITTLE
  output: Proc2 +hex
  AfterMake: fromelf.exe --binCombined -o "$L@L.bin" "#L"
  AfterMake: ../../../../Utility/M7M02_Final/bincopy.exe -i $L@L.bin -o ./proc2_image.c
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c misc: -Wno-unknown-warning-option -Wno-unsafe-buffer-usage -Wno-date-time -Wno-unused-parameter -Wno-missing-noreturn -Wno-unsafe-buffer-usage -Wno-missing-variable-declarations
  c include: ./;../Include/;../../../../Include/;../../../../Guest/
  asm include: ./;../Include/;../../../../Include/;../../../../Guest/
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x8000000 size 0x10000
  scatter file: prc_proc2_stm32l071cb.sct
  link misc: --keep=*_desc
  group Proc2
    ../Source/: prc_proc2_thd_thd1.c prc_proc2_inv_inv1.c prc_proc2_desc.c prc_proc2.c
  group Lib
    ../../../../Guest/: rvm_guest.c
    ../../../../Guest/A6M/: rvm_guest_a6m_armcc.s rvm_guest_a6m.c
